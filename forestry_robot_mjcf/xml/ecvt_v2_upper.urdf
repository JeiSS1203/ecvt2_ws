Commit message: PFRC 뺀 버전

File: forestry_robot_mjcf/xml/ecvt_v2_upper.urdf (robot description, URDF)
Before this commit: robot simple_model_for_urdf.SLDASM, 8 links, 7 joints
Joints:
- joint UPJ5: type revolute -> fixed
- joint UPJ6: type revolute -> fixed
